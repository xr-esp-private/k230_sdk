## boards/k230_canmv_xiaorgeek/Kconfig
```kconfig
if BOARD_K230_CANMV_XIAORGEEK
    config BOARD_NOT_SUPPORT_HW_RTC
        def_bool y
endif
```
